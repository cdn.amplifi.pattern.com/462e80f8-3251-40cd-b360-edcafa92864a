Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2020-10-19T16:42:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200826_1250(x64) - Exporter 20.2.30.42 - Alternate UI 20.2.30.42
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 19 16:42:58 2020 * Host: LAPTOP-FUUL539U * Database: C:\Users\Damien\AppData\Local\Temp\7aa7f7a3-5245-4db6-94eb-65eca3206370\14c45a9d-2be3-4b3b-bb83-413894e05e74\ifc * Database version: 5507 * Database creation date: Mon Oct 19 16:42:57 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 19 16:42:58 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 19 16:42:58 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -35, -18, -23, -549194; RefLongitude: 149, 7, 35, 603027; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - Triangle (AUS): Type 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcBuildingElementProxy: 12mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:12mm ReidBar Half Nut Galvanised:160985
In: Level 1
Type - Material: S.G. Iron Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Hex D: 28.8675 mm; Hex Size A: 25 mm; Hex t: 14.4338 mm; Nut Length: 16 mm; Thread Cut Diameter: 12 mm; Thread Cut Radius: 6 mm
Type - Identity Data - Type Name: 12mm ReidBar Half Nut Galvanised
Type - Materials and Finishes - Material: S.G. Iron Galvanised
Type - Other - Category: Generic Models; Family Name: M_ReidBar Half Nut Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Half Nut Galvanised; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 12mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyProvisionForVoid - Width: 16 mm; Depth: 16 mm
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Schedule Level: Level: Level 1
Dimensions - Area: 0.0014226 m2; Hex End Ref: 16 mm; Nut Offset from Face: 0 mm; Volume: 0.00000685078 m3
Other - Family: M_ReidBar Half Nut Galvanised: 12mm ReidBar Half Nut Galvanised; Family and Type: M_ReidBar Half Nut Galvanised: 12mm ReidBar Half Nut Galvanised; Type: M_ReidBar Half Nut Galvanised: 12mm ReidBar Half Nut Galvanised; Type Id: M_ReidBar Half Nut Galvanised: 12mm ReidBar Half Nut Galvanised
Phasing - Phase Created: Phase 1

# IfcBuildingElementProxy: 16mm ReidBar Flange Nut, M_ReidBar Flange Nut:16mm ReidBar Flange Nut:162108
In: Level 1
Type - Material: S.G. Iron
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Base Angle: 30 deg; Base Depth: 3 mm; FN Base Diameter: 51 mm; FN Base Radius: 25.5 mm; FN Body Diameter: 30 mm; FN Body Radius: 15 mm; FN Length: 50 mm; Hex d: 30 mm; Hex Depth: 25 mm; Hex Ecc: 5 mm; Hex t: 17.3205 mm; Sub Base Depth: 6.06218 mm; Thread Cut Diameter: 16 mm; Thread Cut End: -70 mm; Thread Cut Length: 70 mm; Thread Cut Radius: 8 mm
Type - Identity Data - Type Name: 16mm ReidBar Flange Nut
Type - Materials and Finishes - Material: S.G. Iron
Type - Other - Category: Generic Models; Family Name: M_ReidBar Flange Nut
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 16mm ReidBar Flange Nut
Type - Pset_EnvironmentalImpactIndicators - Reference: 16mm ReidBar Flange Nut
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Schedule Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00549027 m2; Volume: 0.0000345434 m3
Other - Family: M_ReidBar Flange Nut: 16mm ReidBar Flange Nut; Family and Type: M_ReidBar Flange Nut: 16mm ReidBar Flange Nut; Type: M_ReidBar Flange Nut: 16mm ReidBar Flange Nut; Type Id: M_ReidBar Flange Nut: 16mm ReidBar Flange Nut
Phasing - Phase Created: Phase 1

# IfcBuildingElementProxy: 16mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:16mm ReidBar Half Nut Galvanised:162116
In: Level 1
Type - Material: S.G. Iron Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Hex D: 34.641 mm; Hex Size A: 30 mm; Hex t: 17.3205 mm; Nut Length: 20 mm; Thread Cut Diameter: 16 mm; Thread Cut Radius: 8 mm
Type - Identity Data - Type Name: 16mm ReidBar Half Nut Galvanised
Type - Materials and Finishes - Material: S.G. Iron Galvanised
Type - Other - Category: Generic Models; Family Name: M_ReidBar Half Nut Galvanised
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 16mm ReidBar Half Nut Galvanised
Type - Pset_EnvironmentalImpactIndicators - Reference: 16mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyProvisionForVoid - Width: 20 mm; Depth: 20 mm
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Schedule Level: Level: Level 1; Host: Level : Level 1
Dimensions - Nut Offset from Face: 0 mm; Area: 0.00212027 m2; Hex End Ref: 20 mm; Volume: 0.0000115674 m3
Other - Family: M_ReidBar Half Nut Galvanised: 16mm ReidBar Half Nut Galvanised; Family and Type: M_ReidBar Half Nut Galvanised: 16mm ReidBar Half Nut Galvanised; Type: M_ReidBar Half Nut Galvanised: 16mm ReidBar Half Nut Galvanised; Type Id: M_ReidBar Half Nut Galvanised: 16mm ReidBar Half Nut Galvanised
Phasing - Phase Created: Phase 1

# IfcBuildingElementProxy: 20mm ReidBar Flange Nut, M_ReidBar Flange Nut:20mm ReidBar Flange Nut:162117
In: Level 1
Type - Material: S.G. Iron
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Base Angle: 30 deg; Base Depth: 3 mm; FN Base Diameter: 66 mm; FN Base Radius: 33 mm; FN Body Diameter: 35 mm; FN Body Radius: 17.5 mm; FN Length: 50 mm; Hex d: 36 mm; Hex Depth: 20 mm; Hex Ecc: 10 mm; Hex t: 20.7846 mm; Sub Base Depth: 8.94893 mm; Thread Cut Diameter: 20 mm; Thread Cut End: -50 mm; Thread Cut Length: 50 mm; Thread Cut Radius: 10 mm
Type - Identity Data - Type Name: 20mm ReidBar Flange Nut
Type - Materials and Finishes - Material: S.G. Iron
Type - Other - Category: Generic Models; Family Name: M_ReidBar Flange Nut
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 20mm ReidBar Flange Nut
Type - Pset_EnvironmentalImpactIndicators - Reference: 20mm ReidBar Flange Nut
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Schedule Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00744285 m2; Volume: 0.0000526912 m3
Other - Family: M_ReidBar Flange Nut: 20mm ReidBar Flange Nut; Family and Type: M_ReidBar Flange Nut: 20mm ReidBar Flange Nut; Type: M_ReidBar Flange Nut: 20mm ReidBar Flange Nut; Type Id: M_ReidBar Flange Nut: 20mm ReidBar Flange Nut
Phasing - Phase Created: Phase 1

# IfcBuildingElementProxy: 20mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:20mm ReidBar Half Nut Galvanised:162132
In: Level 1
Type - Material: S.G. Iron Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Hex D: 41.5692 mm; Hex Size A: 36 mm; Hex t: 20.7846 mm; Nut Length: 25 mm; Thread Cut Diameter: 20 mm; Thread Cut Radius: 10 mm
Type - Identity Data - Type Name: 20mm ReidBar Half Nut Galvanised
Type - Materials and Finishes - Material: S.G. Iron Galvanised
Type - Other - Category: Generic Models; Family Name: M_ReidBar Half Nut Galvanised
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 20mm ReidBar Half Nut Galvanised
Type - Pset_EnvironmentalImpactIndicators - Reference: 20mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyProvisionForVoid - Width: 25 mm; Depth: 25 mm
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Schedule Level: Level: Level 1; Host: Level : Level 1
Dimensions - Nut Offset from Face: 0 mm; Area: 0.0031525 m2; Hex End Ref: 25 mm; Volume: 0.0000202056 m3
Other - Family: M_ReidBar Half Nut Galvanised: 20mm ReidBar Half Nut Galvanised; Family and Type: M_ReidBar Half Nut Galvanised: 20mm ReidBar Half Nut Galvanised; Type: M_ReidBar Half Nut Galvanised: 20mm ReidBar Half Nut Galvanised; Type Id: M_ReidBar Half Nut Galvanised: 20mm ReidBar Half Nut Galvanised
Phasing - Phase Created: Phase 1

# IfcBuildingElementProxy: 25mm ReidBar Flange Nut, M_ReidBar Flange Nut:25mm ReidBar Flange Nut:162133
In: Level 1
Type - Material: S.G. Iron
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Base Angle: 30 deg; Base Depth: 3 mm; FN Base Diameter: 84 mm; FN Base Radius: 42 mm; FN Body Diameter: 43 mm; FN Body Radius: 21.5 mm; FN Length: 70 mm; Hex d: 46 mm; Hex Depth: 25 mm; Hex Ecc: 9 mm; Hex t: 26.5581 mm; Sub Base Depth: 11.8357 mm; Thread Cut Diameter: 25 mm; Thread Cut End: -70 mm; Thread Cut Length: 70 mm; Thread Cut Radius: 12.5 mm
Type - Identity Data - Type Name: 25mm ReidBar Flange Nut
Type - Materials and Finishes - Material: S.G. Iron
Type - Other - Category: Generic Models; Family Name: M_ReidBar Flange Nut
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 25mm ReidBar Flange Nut
Type - Pset_EnvironmentalImpactIndicators - Reference: 25mm ReidBar Flange Nut
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Schedule Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.012565 m2; Volume: 0.000108779 m3
Other - Family: M_ReidBar Flange Nut: 25mm ReidBar Flange Nut; Family and Type: M_ReidBar Flange Nut: 25mm ReidBar Flange Nut; Type: M_ReidBar Flange Nut: 25mm ReidBar Flange Nut; Type Id: M_ReidBar Flange Nut: 25mm ReidBar Flange Nut
Phasing - Phase Created: Phase 1

# IfcBuildingElementProxy: 25mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:25mm ReidBar Half Nut Galvanised:162136
In: Level 1
Type - Material: S.G. Iron Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Hex D: 53.1162 mm; Hex Size A: 46 mm; Hex t: 26.5581 mm; Nut Length: 31 mm; Thread Cut Diameter: 25 mm; Thread Cut Radius: 12.5 mm
Type - Identity Data - Type Name: 25mm ReidBar Half Nut Galvanised
Type - Materials and Finishes - Material: S.G. Iron Galvanised
Type - Other - Category: Generic Models; Family Name: M_ReidBar Half Nut Galvanised
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 25mm ReidBar Half Nut Galvanised
Type - Pset_EnvironmentalImpactIndicators - Reference: 25mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyProvisionForVoid - Width: 31 mm; Depth: 31 mm
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Schedule Level: Level: Level 1; Host: Level : Level 1
Dimensions - Nut Offset from Face: 0 mm; Area: 0.00502897 m2; Hex End Ref: 31 mm; Volume: 0.0000415914 m3
Other - Family: M_ReidBar Half Nut Galvanised: 25mm ReidBar Half Nut Galvanised; Family and Type: M_ReidBar Half Nut Galvanised: 25mm ReidBar Half Nut Galvanised; Type: M_ReidBar Half Nut Galvanised: 25mm ReidBar Half Nut Galvanised; Type Id: M_ReidBar Half Nut Galvanised: 25mm ReidBar Half Nut Galvanised
Phasing - Phase Created: Phase 1

# IfcBuildingElementProxy: 32mm ReidBar Flange Nut, M_ReidBar Flange Nut:32mm ReidBar Flange Nut:162137
In: Level 1
Type - Material: S.G. Iron
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Base Angle: 24 deg; Base Depth: 5 mm; FN Base Diameter: 101 mm; FN Base Radius: 50.5 mm; FN Body Diameter: 55 mm; FN Body Radius: 27.5 mm; FN Length: 95 mm; Hex d: 57 mm; Hex Depth: 32 mm; Hex Ecc: 13 mm; Hex t: 32.909 mm; Sub Base Depth: 10.2403 mm; Thread Cut Diameter: 32 mm; Thread Cut End: -95 mm; Thread Cut Length: 95 mm; Thread Cut Radius: 16 mm
Type - Identity Data - Type Name: 32mm ReidBar Flange Nut
Type - Materials and Finishes - Material: S.G. Iron
Type - Other - Category: Generic Models; Family Name: M_ReidBar Flange Nut
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 32mm ReidBar Flange Nut
Type - Pset_EnvironmentalImpactIndicators - Reference: 32mm ReidBar Flange Nut
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Schedule Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.0203859 m2; Volume: 0.000216951 m3
Other - Family: M_ReidBar Flange Nut: 32mm ReidBar Flange Nut; Family and Type: M_ReidBar Flange Nut: 32mm ReidBar Flange Nut; Type: M_ReidBar Flange Nut: 32mm ReidBar Flange Nut; Type Id: M_ReidBar Flange Nut: 32mm ReidBar Flange Nut
Phasing - Phase Created: Phase 1

# IfcBuildingElementProxy: 32mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:32mm ReidBar Half Nut Galvanised:162140
In: Level 1
Type - Material: S.G. Iron Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Hex D: 63.5085 mm; Hex Size A: 55 mm; Hex t: 31.7543 mm; Nut Length: 39 mm; Thread Cut Diameter: 32 mm; Thread Cut Radius: 16 mm
Type - Identity Data - Type Name: 32mm ReidBar Half Nut Galvanised
Type - Materials and Finishes - Material: S.G. Iron Galvanised
Type - Other - Category: Generic Models; Family Name: M_ReidBar Half Nut Galvanised
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: 32mm ReidBar Half Nut Galvanised
Type - Pset_EnvironmentalImpactIndicators - Reference: 32mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyProvisionForVoid - Width: 39 mm; Depth: 39 mm
Constraints - Elevation from Level: 0 mm; Level: Level: Level 1; Schedule Level: Level: Level 1; Host: Level : Level 1
Dimensions - Nut Offset from Face: 0 mm; Area: 0.00749119 m2; Hex End Ref: 39 mm; Volume: 0.0000708052 m3
Other - Family: M_ReidBar Half Nut Galvanised: 32mm ReidBar Half Nut Galvanised; Family and Type: M_ReidBar Half Nut Galvanised: 32mm ReidBar Half Nut Galvanised; Type: M_ReidBar Half Nut Galvanised: 32mm ReidBar Half Nut Galvanised; Type Id: M_ReidBar Half Nut Galvanised: 32mm ReidBar Half Nut Galvanised
Phasing - Phase Created: Phase 1
